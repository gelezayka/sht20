# Keil uVision project sht20.uvproj, settings and files
target N76E300 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: sht20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include
  group Startup
    ./Startup/: STARTUP.A51
  group User
    ./User/: main.c PetitModbus.c PetitModbusPort.c PetitRegConstant.c
  group Common
    ./Common/: Common.c Delay.c I2C.c
